<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>BAN_modems</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>EBW</value></param>
<param><key>comment</key><value>Excess Band Width:(sharpness the cut-off edge)
0 is the sharpest</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>RRC_filter_taps</value></param>
<param><key>comment</key><value>Root raised cosine definition.</value></param>
<param><key>alpha</key><value>EBW</value></param>
<param><key>gain</key><value>nfilts</value></param>
<param><key>ntaps</key><value>5*SPS*nfilts/RX_decimation</value></param>
<param><key>samp_rate</key><value>nfilts</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>offset_freq</value></param>
<param><key>comment</key><value>This is the offset frequncy for TX/RX.
Required &gt; 0Hz.
Required not overlap with other frequnency in multiple channels.</value></param>
<param><key>value</key><value>int(carrier_freq-center_freq)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>FSK_index_num</value></param>
<param><key>comment</key><value>Index Number of GFSK.
Index = 1 is MSK.
Lower index means narrow BW but maybe less accurate.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>MSK_FSK_demod</key>
<param><key>id</key><value>MSK_FSK_demod_0</value></param>
<param><key>hdr_format</key><value>digital.header_format_default(digital.packet_utils.default_access_code, 0)</value></param>
<param><key>RX_decimation</key><value>RX_decimation</value></param>
<param><key>carrier_freq</key><value>carrier_freq</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>dst</key><value>dst</value></param>
<param><key>file_name</key><value>'test_out'</value></param>
<param><key>fsk_deviation_hz</key><value>int(5e3)</value></param>
<param><key>index_num</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>MSK_FSK_mod</key>
<param><key>id</key><value>MSK_FSK_mod_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>carrier_freq</key><value>carrier_freq</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>fsk_deviation_hz</key><value>fsk_deviation_hz</value></param>
<param><key>index_num</key><value>FSK_index_num</value></param>
<param><key>noise_amp</key><value>noise_amp</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>PSK_mod</key>
<param><key>id</key><value>PSK_mod_0</value></param>
<param><key>my_const</key><value>digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()</value></param>
<param><key>SPS</key><value>200</value></param>
<param><key>carrier_freq</key><value>int(270e3)</value></param>
<param><key>center_freq</key><value>int(100e3)</value></param>
<param><key>noise_amp</key><value>0.7</value></param>
<param><key>samp_rate</key><value>int(2e6)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>RX_IF_gain</value></param>
<param><key>comment</key><value>Try IF gain first to amplify signal.
Constrainted by power supply.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>RX_RF_gain</value></param>
<param><key>comment</key><value>Increase RF gain will amplify siganl.
But may introduce more noise.
Use if IF gain is not enough.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>RX_decimation</value></param>
<param><key>comment</key><value>Receiver decimation factor.
larger number means lower BW of LPF.
Must be common divisor of SPS.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>SPS</value></param>
<param><key>comment</key><value>Sample per Symbol for PSK/OOK
Up-sample the generated frequency.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>Signal_Generator</key>
<param><key>id</key><value>Signal_Generator_0</value></param>
<param><key>hdr_format</key><value>digital.header_format_default(digital.packet_utils.default_access_code, 0)</value></param>
<param><key>dst</key><value>dst</value></param>
<param><key>file_name</key><value>'test_in'</value></param>
<param><key>interval_ms</key><value>int(0.2e3)</value></param>
<param><key>message</key><value>message</value></param>
<param><key>message_repeatNum</key><value>3</value></param>
<param><key>samp_rate</key><value>int(2e6)</value></param>
<param><key>symbol_rate</key><value>int(2e6)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>TX_IF_gain</value></param>
<param><key>comment</key><value>Try IF gain first to amplify signal.
Constrainted by power supply.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>TX_RF_gain</value></param>
<param><key>comment</key><value>Increase RF gain will amplify siganl.
But may introduce more noise.
Use if IF gain is not enough.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>carrier_freq</value></param>
<param><key>comment</key><value>Desired carrier frequency.
Less fequency cause requires less samp_rate
Constrains by transimission device</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(270e3)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>comment</key><value>Desired center frequency for FSK.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(10e3)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dst</value></param>
<param><key>comment</key><value>Desination of saved signal files</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>C:\Users\cheny\Desktop\</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fsk_deviation_hz</value></param>
<param><key>comment</key><value>Frequency deviation of GFSK modulation.
Required to be index*sps*symbol_rate/4.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(5e3)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hdr_format</value></param>
<param><key>comment</key><value>Header format definition</value></param>
<param><key>label</key><value>Header Formatter</value></param>
<param><key>value</key><value>digital.header_format_default(digital.packet_utils.default_access_code, 0)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>comment</key><value>Custom Embedded
Python Block uses 
this library.</value></param>
<param><key>import</key><value>import numpy; from gnuradio import digital</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>message</value></param>
<param><key>comment</key><value>Recommend using long message
to achieve accurate test BER!</value></param>
<param><key>value</key><value>"Here's an example of how GRC can be used to create a simulation environment. The following flow graph is available as part of the Channel Coding toolbox and was used to demonstrate the capabilities of the included Reed-Muller-Golay code. The original CGRAN server is offline, the code from the channel coding toolbox has been uploaded to github.com/ckuethe/gr-chancoding and is unlikely to work without some work to use newer GNU Radio APIs.A very important thing to observe is the use of the throttle block (the first block after the random source). This block only allows a certain amount of bits to pass the block (this is not an exact rate, but the average rate of bits leaving this block will be the given sampling rate). If you omit the throttle block, you risk your CPU running the flow graph at full speed ."</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>noise_amp</value></param>
<param><key>comment</key><value>Noise amplitute for simulation.</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.6</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>16</value></param>
<param><key>freq0</key><value>offset_freq</value></param>
<param><key>if_gain0</key><value>TX_IF_gain</value></param>
<param><key>gain0</key><value>TX_RF_gain</value></param>
<param><key>comment</key><value>Contol the transmitter.</value></param>
<param><key>args</key><value>hackrf=232a2c5f</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>16</value></param>
<param><key>freq0</key><value>offset_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>RX_IF_gain</value></param>
<param><key>gain0</key><value>RX_RF_gain</value></param>
<param><key>args</key><value>hackrf=2226255f</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>comment</key><value>The sample rate of generated signal. 
Require &gt;=BW of the transmitter and receiver.
Less sample rate cause less power.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(2e6)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>comment</key><value>The symbol rate of the message.
Depends on the actual user case
Required to be &lt;= sample rate.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(2e6)</value></param>
</block>
<connection><source_block_id>MSK_FSK_mod_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PSK_mod_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Signal_Generator_0</source_block_id><sink_block_id>MSK_FSK_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Signal_Generator_0</source_block_id><sink_block_id>PSK_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>MSK_FSK_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
