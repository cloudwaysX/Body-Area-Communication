<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>BAN_modems</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>offset_freq</value></param>
<param><key>comment</key><value>This is the offset frequncy for TX/RX.
Required &gt; 0Hz.
Required not overlap with other frequnency in multiple channels.</value></param>
<param><key>value</key><value>int(carrier_freq-center_freq)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>BandWidth</value></param>
<param><key>comment</key><value>Zero-centered Bandwidth</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(5e3)*2</value></param>
</block>
<block>
<key>MSK_FSK_demod</key>
<param><key>id</key><value>MSK_FSK_demod_0</value></param>
<param><key>RX_decimation</key><value>100</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>fsk_deviation_hz</key><value>int(5e3)</value></param>
<param><key>index_num</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>symbol_rate</key><value>symbol_rate</value></param>
</block>
<block>
<key>MSK_FSK_mod</key>
<param><key>id</key><value>MSK_FSK_mod_0</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>fsk_deviation_hz</key><value>BandWidth/2</value></param>
<param><key>index_num</key><value>2</value></param>
<param><key>interval_ms</key><value>interval_ms</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>symbol_rate</key><value>symbol_rate</value></param>
</block>
<block>
<key>OOK_demod</key>
<param><key>id</key><value>OOK_demod_0</value></param>
<param><key>BW</key><value>BandWidth</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>RX_decimation</key><value>125</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>symbol_rate</key><value>int(2e6)</value></param>
</block>
<block>
<key>OOK_mod</key>
<param><key>id</key><value>OOK_mod_0</value></param>
<param><key>BW</key><value>BandWidth</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>symbol_rate</key><value>int(2e6)</value></param>
</block>
<block>
<key>PSK_demod</key>
<param><key>id</key><value>PSK_demod_0</value></param>
<param><key>BW</key><value>BandWidth</value></param>
<param><key>my_const</key><value>digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()</value></param>
<param><key>EBW</key><value>0.35</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>RX_decimation</key><value>50</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>symbol_rate</key><value>int(2e6)</value></param>
</block>
<block>
<key>PSK_mod</key>
<param><key>id</key><value>PSK_mod_0</value></param>
<param><key>BW</key><value>BandWidth</value></param>
<param><key>my_const</key><value>digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()</value></param>
<param><key>EBW</key><value>0.35</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>symbol_rate</key><value>int(2e6)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>RX_IF_gain</value></param>
<param><key>comment</key><value>Try IF gain first to amplify signal.
Constrainted by power supply.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>RX_RF_gain</value></param>
<param><key>comment</key><value>Increase RF gain will amplify siganl.
But may introduce more noise.
Use if IF gain is not enough.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>14</value></param>
</block>
<block>
<key>Ref_Sychronize</key>
<param><key>id</key><value>Ref_Sychronize_0</value></param>
<param><key>comment</key><value>Sychronize the Reference signal ans Demoded Signal
Save sychronized signal
Used for BER check</value></param>
<param><key>dst</key><value>dst</value></param>
<param><key>file_name</key><value>'10B_100m_noise9_004_galv_po3_out_f700'</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>threshold</key><value>syc_threshold</value></param>
</block>
<block>
<key>Signal_Generator</key>
<param><key>id</key><value>Signal_Generator_0</value></param>
<param><key>hdr_format</key><value>digital.header_format_default(digital.packet_utils.default_access_code, 0)</value></param>
<param><key>dst</key><value>dst</value></param>
<param><key>file_name</key><value>'10B_100m_noise9_004_galv_po3_in_f700'</value></param>
<param><key>interval_ms</key><value>interval_ms</value></param>
<param><key>message</key><value>message</value></param>
<param><key>message_repeatNum</key><value>100</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>symbol_rate</key><value>symbol_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>TX_IF_gain</value></param>
<param><key>comment</key><value>Try IF gain first to amplify signal.
Constrainted by power supply.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>47</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>TX_RF_gain</value></param>
<param><key>comment</key><value>Increase RF gain will amplify siganl.
But may introduce more noise.
Use if IF gain is not enough.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>14</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>0.0</value></param>
<param><key>freq</key><value>-400e3</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>carrier_freq</value></param>
<param><key>comment</key><value>Desired carrier frequency.
Less fequency cause requires less samp_rate
Constrains by transimission device</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(700e3)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>comment</key><value>Desired center frequency for FSK.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(30e3)</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>0.0</value></param>
<param><key>noise_voltage</key><value>noise_amp</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0 + 1.0j</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dst</value></param>
<param><key>comment</key><value>Desination of saved signal files</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>C:\Users\cheny\Documents\Body-Area-Communication\data\Galvanic3\</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hdr_format</value></param>
<param><key>comment</key><value>Header format definition</value></param>
<param><key>label</key><value>Header Formatter</value></param>
<param><key>value</key><value>digital.header_format_default(digital.packet_utils.default_access_code, 0)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>comment</key><value>Custom Embedded
Python Block uses 
this library.</value></param>
<param><key>import</key><value>import numpy; from gnuradio import digital;import string;import random</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>interval_ms</value></param>
<param><key>comment</key><value>Time interval between each message
Right now haven't see any influnce on BER
unit: ms</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(150)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>message</value></param>
<param><key>comment</key><value>Recommend using long message
to achieve accurate test BER!</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>Helloworld</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>noise_amp</value></param>
<param><key>comment</key><value>Noise amplitute for simulation.</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.0</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>16</value></param>
<param><key>freq0</key><value>offset_freq</value></param>
<param><key>if_gain0</key><value>TX_IF_gain</value></param>
<param><key>gain0</key><value>TX_RF_gain</value></param>
<param><key>comment</key><value>Contol the transmitter.</value></param>
<param><key>args</key><value>hackrf=295a8ccf</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>16</value></param>
<param><key>freq0</key><value>offset_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>RX_IF_gain</value></param>
<param><key>gain0</key><value>RX_RF_gain</value></param>
<param><key>args</key><value>hackrf=2226255f</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>comment</key><value>The sample rate of generated signal. 
Require &gt;=BW of the transmitter and receiver.
Less sample rate cause less power.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(2e6)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>syc_threshold</value></param>
<param><key>comment</key><value>Number of errors allowed in access code</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>comment</key><value>The symbol rate of the message.
Depends on the actual user case
Required to be &lt;= sample rate.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(2e6)</value></param>
</block>
<connection><source_block_id>MSK_FSK_demod_0</source_block_id><sink_block_id>Ref_Sychronize_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>MSK_FSK_mod_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>OOK_demod_0</source_block_id><sink_block_id>Ref_Sychronize_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>OOK_mod_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PSK_demod_0</source_block_id><sink_block_id>Ref_Sychronize_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PSK_mod_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Signal_Generator_0</source_block_id><sink_block_id>MSK_FSK_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Signal_Generator_0</source_block_id><sink_block_id>OOK_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Signal_Generator_0</source_block_id><sink_block_id>PSK_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Signal_Generator_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>MSK_FSK_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>OOK_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>PSK_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
