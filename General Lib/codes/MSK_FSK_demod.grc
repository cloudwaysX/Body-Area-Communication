<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>MSK_FSK_demod</value></param>
<param><key>generate_options</key><value>hb_qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>EBW</value></param>
<param><key>comment</key><value>Excess Band Width:(sharpness the cut-off edge)
0 is the sharpest</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>RRC_filter_taps</value></param>
<param><key>comment</key><value>Root raised cosine definition.</value></param>
<param><key>alpha</key><value>EBW</value></param>
<param><key>gain</key><value>nfilts</value></param>
<param><key>ntaps</key><value>5*SPS*nfilts/RX_decimation</value></param>
<param><key>samp_rate</key><value>nfilts</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>SPS</value></param>
<param><key>comment</key><value>Sample per Symbol.
Up-sample the generated frequency.</value></param>
<param><key>value</key><value>int(samp_rate/fsk_deviation_hz/4)*int(index_num)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>offset_freq</value></param>
<param><key>comment</key><value>This is the offset frequncy for TX/RX.
Required &gt; 0Hz.
Required not overlap with other frequnency in multiple channels.</value></param>
<param><key>value</key><value>int(carrier_freq-center_freq)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>whole_name</value></param>
<param><key>comment</key><value>Name of signal file.
Dst(Destination) + file_name</value></param>
<param><key>value</key><value>dst+ file_name</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>RX_decimation</value></param>
<param><key>comment</key><value>Receiver decimation factor.
larger number means lower BW of LPF.
Must be common divisor of SPS.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>analog_feedforward_agc_cc</key>
<param><key>id</key><value>analog_feedforward_agc_cc_0</value></param>
<param><key>comment</key><value>Optional 
AGC (normailze the amplitude)</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>num_samples</key><value>1024</value></param>
<param><key>reference</key><value>1.0</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0_0</value></param>
<param><key>alpha</key><value>.01</value></param>
<param><key>comment</key><value>Optional power
squelch</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>-60</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>comment</key><value>FSK demod</value></param>
<param><key>gain</key><value>samp_rate/(2*math.pi*fsk_deviation_hz/8.0)/(RX_decimation)</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>-center_freq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>whole_name</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0</value></param>
<param><key>comment</key><value>Display the message that was sent.</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1</value></param>
<param><key>comment</key><value>Perform frequency 
translation (down convert)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_0_0_0</value></param>
<param><key>k</key><value>1</value></param>
<param><key>l</key><value>8</value></param>
<param><key>comment</key><value>Tagged Stream to PDU block up ahead needs packed bytes</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value>len_key2</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>len_key2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>carrier_freq</value></param>
<param><key>comment</key><value>Desired carrier frequency.
Less fequency cause requires less samp_rate
Constrains by transimission device</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(270e3)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>comment</key><value>Desired center frequency for FSK.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(10e3)</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_correlate_access_code_xx_ts</key>
<param><key>id</key><value>digital_correlate_access_code_xx_ts_1_0_0</value></param>
<param><key>access_code</key><value>digital.packet_utils.default_access_code</value></param>
<param><key>comment</key><value>Correlates with access code to extract the payload.</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>len_key2</value></param>
<param><key>threshold</key><value>10</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>comment</key><value>Clock sync</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>6.28/400.0*2/70</value></param>
<param><key>max_dev</key><value>2</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>SPS/RX_decimation</value></param>
<param><key>taps</key><value>RRC_filter_taps</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dst</value></param>
<param><key>comment</key><value>Desination of saved signal files</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>C:\Users\cheny\Desktop\</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>file_name</value></param>
<param><key>comment</key><value>Specific name of the file</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>test_out</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fsk_deviation_hz</value></param>
<param><key>comment</key><value>Frequency deviation of GFSK modulation.
Required to be index*sps*symbol_rate/4.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(5e3)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hdr_format</value></param>
<param><key>comment</key><value>Header format definition</value></param>
<param><key>label</key><value>Header Formatter</value></param>
<param><key>value</key><value>digital.header_format_default(digital.packet_utils.default_access_code, 0)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>comment</key><value>Custom Embedded
Python Block uses 
this library.</value></param>
<param><key>import</key><value>import numpy; from gnuradio import digital</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>index_num</value></param>
<param><key>comment</key><value>Index Number of GFSK.
Index = 1 is MSK.
Lower index means narrow BW but maybe less accurate.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>comment</key><value>Visualization for the received 2 bits information in the frequncy domain</value></param>
<param><key>fftsize</key><value>512</value></param>
<param><key>name</key><value>"RX Signal in Frequency Domain"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>comment</key><value>After Demodulation.
Visualization for the received 2 bits information in the time domain</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Demoded RX Signal in Time Domain"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>RX_decimation</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>comment</key><value>The sample rate of generated signal. 
Require &gt;=BW of the transmitter and receiver.
Less sample rate cause less power.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(2e6)</value></param>
</block>
<connection><source_block_id>analog_feedforward_agc_cc_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0_0</source_block_id><sink_block_id>analog_feedforward_agc_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_0_0_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0</source_block_id><sink_block_id>blocks_message_debug_0_0</sink_block_id><source_key>pdus</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>digital_correlate_access_code_xx_ts_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_xx_ts_1_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_xx_ts_1_0_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>analog_pwr_squelch_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
