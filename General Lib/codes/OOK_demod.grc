<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>OOK_demod</value></param>
<param><key>generate_options</key><value>hb_qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>EBW2</value></param>
<param><key>value</key><value>00.35</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>RRC_filter_taps</value></param>
<param><key>comment</key><value>Root raised cosine definition.</value></param>
<param><key>alpha</key><value>EBW2</value></param>
<param><key>gain</key><value>nfilts</value></param>
<param><key>ntaps</key><value>5*SPS*nfilts/RX_decimation</value></param>
<param><key>samp_rate</key><value>nfilts</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>SPS</value></param>
<param><key>comment</key><value>Sample per Symbol.
Up-sample the generated frequency.
noise&lt;SPS&lt;samp_rate/bandWidth</value></param>
<param><key>value</key><value>symbol_rate/ideal_BW*10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>EBW</value></param>
<param><key>comment</key><value>zero-centered band width</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>RX_decimation</value></param>
<param><key>comment</key><value>Receiver decimation factor.
larger number means lower BW of LPF.
Must be common divisor of SPS.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>125</value></param>
</block>
<block>
<key>analog_feedforward_agc_cc</key>
<param><key>id</key><value>analog_feedforward_agc_cc_0</value></param>
<param><key>comment</key><value>Optional AGC</value></param>
<param><key>num_samples</key><value>1024/2</value></param>
<param><key>reference</key><value>1.0</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0_0</value></param>
<param><key>alpha</key><value>.01</value></param>
<param><key>comment</key><value>Optional power
squelch</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>-60</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>-center_freq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>SPS/RX_decimation</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>4.0/SPS*RX_decimation</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1</value></param>
<param><key>comment</key><value>Perform frequency 
translation (down convert)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>1</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>comment</key><value>Desired center frequency for PSK.
better to be &gt;= 30K</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(30e3)</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>comment</key><value>Clock sync and
recover the original 
symbol rate</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>6.28/400.0*2/70</value></param>
<param><key>max_dev</key><value>2</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>SPS/RX_decimation</value></param>
<param><key>taps</key><value>RRC_filter_taps</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>generatedSignal</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ideal_BW</value></param>
<param><key>comment</key><value>zero-centered band width</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(5e3)*2</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>comment</key><value>Custom Embedded
Python Block uses 
this library.</value></param>
<param><key>import</key><value>import numpy; from gnuradio import digital</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>comment</key><value>Visualization for the received 2 bits information in the frequncy domain</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>"RX Signal in Frequency Domain"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>comment</key><value>Visualization for the received 2 bits information in the frequncy domain
After the Low Pass Filter</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>"LPF RX Signal in Frequency Domain"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Moving average"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>RX_decimation</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>comment</key><value>The sample rate of generated signal. 
Require &gt;=BW of the transmitter and receiver.
Less sample rate cause less power.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(2e6)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>comment</key><value>The symbol rate of the message.
Depends on the actual user case
Required to be &lt;= sample rate.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(2e6)</value></param>
</block>
<connection><source_block_id>analog_feedforward_agc_cc_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0_0</source_block_id><sink_block_id>analog_feedforward_agc_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>generatedSignal</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>analog_pwr_squelch_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
